# Keil uVision project firstProject.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: firstProject +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\Libs;C:\Keil_v5\ARM\ARMCLANG\lib\clang\15.0.0\include;..\..\Drivers\Common;..\..\Drivers\CpuDriver\inc;..\..\Drivers\IntCtrl\inc;..\..\Drivers\Dio\inc;..\..\Drivers\MCU\inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Mcal
    ../firstProject/src/Mcal/: IntCtrl.c
    ../../Drivers/CpuDriver/src/: Cpu_Driver.c
    ../../Drivers/Dio/src/: Dio.c
    ../../Drivers/MCU/src/: Mcu.c
  group Appl
    ../firstProject/src/Appl/: main.c
  group Config
    ../firstProject/src/Config/: IntCtrl_Cfg.c
    ../../Drivers/MCU/src/: Mcu_Cfg.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
